<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\EVALKIT_ROBOT_1_SDK544_Positioning_LL.ewp</path>
  </project>
  <batchBuild />
</workspace>
